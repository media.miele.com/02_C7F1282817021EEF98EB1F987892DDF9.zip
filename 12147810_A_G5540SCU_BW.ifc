Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b1cddf88-5b63-4bb9-8ef2-9fcce6bea2c5, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-23T05:29:54+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12147810_A_G5540SCU_BW:21554036_A_12147810_G5540SCU_BW, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_BRWS, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Steel_Chrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 448 mm; Height: 805 mm; Depth: 570 mm
Classification: E1030.80 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 21554036_A_12147810_G5540SCU_BW; sets with these values: 2

# IfcDistributionPort, Port_357890_1
Description: Flow; FlowDirection: SOURCEANDSINK
